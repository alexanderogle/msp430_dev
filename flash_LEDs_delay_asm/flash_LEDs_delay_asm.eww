<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\flash_LEDs_delay_asm.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\LEDs_and_buttons_asm_RAM\LEDs_and_buttons_asm_RAM.ewp</path>
  </project>
  <batchBuild/>
</workspace>


