<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\LEDs_and_buttons_C.ewp</path>
  </project>
  <batchBuild/>
</workspace>


